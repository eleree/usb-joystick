# Keil uVision project ch55x.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: ch55x +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\Main
  group Startup
    ./Startup/: STARTUP.A51
  group Main
    ./Main/: main.c
  group Public
    ./Public/: Debug.C
  group App
    ./App/: joystick.c
